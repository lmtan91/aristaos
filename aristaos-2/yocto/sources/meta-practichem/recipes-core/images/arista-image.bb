SUMMARY = "A console-only image that fully supports the target device \
hardware."

LICENSE = "MIT"

require recipes-core/images/core-image-base.bb