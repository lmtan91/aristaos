FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0005-Revert-net-fec-fix-the-warning-found-by-dma-debug.patch"
