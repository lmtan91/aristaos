
SRC_URI += "file://0001-QMX6-U-BOOT-Enable-Q7-GPIO-pins-use-in-environment-s.patch"
